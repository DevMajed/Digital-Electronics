** CMOS_inverter **
*
* NI Multisim to SPICE Netlist Export
* Generated by: majed
* Thu, Jun 18, 2020 03:11:48
*

*## Multisim Component C1 ##*
cC1 1 0 5e-013

*## Multisim Instrument XSC1 ##*

*## Multisim Component V1 ##*
vV1 2 0 ac 1 0
+   distof1 0 0
+   distof2 0 0
+   pulse(0 3.3 0 0 0 1e-007 2e-007)

*## Multisim Component VDD ##*
VDDVDD  VDD 0 dc 5

*## Multisim Component Q2 ##*
mQ2 VDD 2 1 VDD PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q1 ##*
mQ1 1 2 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

.model PMOS__TRANSISTORS_VIRTUAL__1 pmos

.model NMOS__TRANSISTORS_VIRTUAL__1   nmos
