** Design1 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: majed
* Thu, Jun 18, 2020 02:07:12
*

*## Multisim Component D4 ##*
dD4 0 9 1N4148__SWITCHING_DIODE__1

*## Multisim Component D3 ##*
dD3 0 6 1N4148__SWITCHING_DIODE__1

*## Multisim Component C3 ##*
* !!!BEGIN-INTERACT
*  : delay_factor ++++i2   ;
*  : setval       ++++f4   ;
*  : ratedval     ++++f6   ;
*  : init_cond    ++++f8   ;
*  0          constant  S_OK
*  1e-15      VARIABLE  capblown
*  0.0        VARIABLE  flag
*  0.0        VARIABLE  r1Cur
*  0.0        VARIABLE  c1Voltage
*  0.0        VARIABLE  resistance
*  0          VARIABLE  cnt
*  1          VARIABLE  delaytime
*  0          VARIABLE  S_BLOWN
*
* : DELAY
*  *delaytime  0 do
*          *cnt 1+ ==>_*cnt
*          *cnt *delaytime =  if
*          *S_BLOWN 1 + ==>_*S_BLOWN
*          0 ==>_*cnt
*          endif
*   loop
*   *S_BLOWN ==>_*animation_state
* ;
*
* : RESET
*       delay_factor 10000 * ==>_*delaytime
*       0.0 ==>_*flag
*       0.0 ==>_*c1Voltage
*       0.0 ==>_*r1Cur
*       1e15 ==>_*resistance
*       S_OK   ==>_*animation_state
*       0 ==>_*S_BLOWN
* ;
*
*  :BEGIN_PLOT
*         RESET
*  ;
*
*  : C_BLOWN
*      *capblown  resistance   GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value     SET_INSTANCE Resistor ::R r1 resistance
*  ;
*
*  :OUT_DATA
*   1.0 *flag f.> if
*     GET_INSTANCE Resistor ::R r1  i  ==>_*r1Cur
*     *r1Cur f.abs 1e30 f.* ==>_*c1Voltage
*     ratedval *c1Voltage f.< if
*          1.0 ==>_*flag
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          C_BLOWN
*     endif
*   endif
*  ;
*
* :BEGIN_ANALYSIS
*     RESET
* ;
*
* !!!END-INTERACT
xC3 0 8 virtual_capC3
.subckt virtual_capC3 1 2
r1 1 2 1e30
c1 1 2 1e-006  IC=0
.ends

*## Multisim Component C2 ##*
* !!!BEGIN-INTERACT
*  : delay_factor ++++i2   ;
*  : setval       ++++f4   ;
*  : ratedval     ++++f6   ;
*  : init_cond    ++++f8   ;
*  0          constant  S_OK
*  1e-15      VARIABLE  capblown
*  0.0        VARIABLE  flag
*  0.0        VARIABLE  r1Cur
*  0.0        VARIABLE  c1Voltage
*  0.0        VARIABLE  resistance
*  0          VARIABLE  cnt
*  1          VARIABLE  delaytime
*  0          VARIABLE  S_BLOWN
*
* : DELAY
*  *delaytime  0 do
*          *cnt 1+ ==>_*cnt
*          *cnt *delaytime =  if
*          *S_BLOWN 1 + ==>_*S_BLOWN
*          0 ==>_*cnt
*          endif
*   loop
*   *S_BLOWN ==>_*animation_state
* ;
*
* : RESET
*       delay_factor 10000 * ==>_*delaytime
*       0.0 ==>_*flag
*       0.0 ==>_*c1Voltage
*       0.0 ==>_*r1Cur
*       1e15 ==>_*resistance
*       S_OK   ==>_*animation_state
*       0 ==>_*S_BLOWN
* ;
*
*  :BEGIN_PLOT
*         RESET
*  ;
*
*  : C_BLOWN
*      *capblown  resistance   GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value     SET_INSTANCE Resistor ::R r1 resistance
*  ;
*
*  :OUT_DATA
*   1.0 *flag f.> if
*     GET_INSTANCE Resistor ::R r1  i  ==>_*r1Cur
*     *r1Cur f.abs 1e30 f.* ==>_*c1Voltage
*     ratedval *c1Voltage f.< if
*          1.0 ==>_*flag
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          C_BLOWN
*     endif
*   endif
*  ;
*
* :BEGIN_ANALYSIS
*     RESET
* ;
*
* !!!END-INTERACT
xC2 7 9 virtual_capC2
.subckt virtual_capC2 1 2
r1 1 2 1e30
c1 1 2 1e-006  IC=0
.ends

*## Multisim Component D5 ##*
dD5 9 8 1N4148__SWITCHING_DIODE__1

*## Multisim Component V1 ##*
vV1 7 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 10 200 0 0 0)

*## Multisim Instrument XSC3 ##*

*## Multisim Component C1 ##*
* !!!BEGIN-INTERACT
*  : delay_factor ++++i2   ;
*  : setval       ++++f4   ;
*  : ratedval     ++++f6   ;
*  : init_cond    ++++f8   ;
*  0          constant  S_OK
*  1e-15      VARIABLE  capblown
*  0.0        VARIABLE  flag
*  0.0        VARIABLE  r1Cur
*  0.0        VARIABLE  c1Voltage
*  0.0        VARIABLE  resistance
*  0          VARIABLE  cnt
*  1          VARIABLE  delaytime
*  0          VARIABLE  S_BLOWN
*
* : DELAY
*  *delaytime  0 do
*          *cnt 1+ ==>_*cnt
*          *cnt *delaytime =  if
*          *S_BLOWN 1 + ==>_*S_BLOWN
*          0 ==>_*cnt
*          endif
*   loop
*   *S_BLOWN ==>_*animation_state
* ;
*
* : RESET
*       delay_factor 10000 * ==>_*delaytime
*       0.0 ==>_*flag
*       0.0 ==>_*c1Voltage
*       0.0 ==>_*r1Cur
*       1e15 ==>_*resistance
*       S_OK   ==>_*animation_state
*       0 ==>_*S_BLOWN
* ;
*
*  :BEGIN_PLOT
*         RESET
*  ;
*
*  : C_BLOWN
*      *capblown  resistance   GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value     SET_INSTANCE Resistor ::R r1 resistance
*  ;
*
*  :OUT_DATA
*   1.0 *flag f.> if
*     GET_INSTANCE Resistor ::R r1  i  ==>_*r1Cur
*     *r1Cur f.abs 1e30 f.* ==>_*c1Voltage
*     ratedval *c1Voltage f.< if
*          1.0 ==>_*flag
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          C_BLOWN
*     endif
*   endif
*  ;
*
* :BEGIN_ANALYSIS
*     RESET
* ;
*
* !!!END-INTERACT
xC1 5 6 virtual_capC1
.subckt virtual_capC1 1 2
r1 1 2 1e30
c1 1 2 1e-006  IC=0
.ends

*## Multisim Component V6 ##*
vV6 5 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 10 200 0 0 0)

*## Multisim Instrument XSC2 ##*

*## Multisim Component V4 ##*
vV4 3 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 10 200 0 0 0)

*## Multisim Instrument XSC1 ##*

*## Multisim Component D2 ##*
dD2 4 2 1N4148__SWITCHING_DIODE__1

*## Multisim Component V3 ##*
vV3 0 1 dc 7 ac 0 0
+           distof1 0 0
+           distof2 0 0

*## Multisim Component V2 ##*
vV2 2 0 dc 4 ac 0 0
+           distof1 0 0
+           distof2 0 0

*## Multisim Component D1 ##*
dD1 1 4 1N4148__SWITCHING_DIODE__1

*## Multisim Component R1 ##*
* !!!BEGIN-INTERACT
*  : delay_factor  ++++i2  ;
*  : setval        ++++f4   ;
*  : ratedval      ++++f6   ;
*  : temp_set      ++++f8   ;
*  : alpha_tc_set  ++++f10  ;
*  : beta_tc_set   ++++f12  ;
*  : tnom_set      ++++f14  ;

*  0        constant  S_OK
*  1e15     constant blown
*  0        VARIABLE Rinit
*  0        VARIABLE cnt
*  1        VARIABLE delaytime
*  0        VARIABLE S_BLOWN
*  0.0      VARIABLE resistance
*  0.0      VARIABLE resrated
*  0.0      VARIABLE restemp
*  0.0      VARIABLE restca
*  0.0      VARIABLE restcb
*  0.0      VARIABLE restnom
*  0.0      VARIABLE tempdiff
*  0.0      VARIABLE tempeffa
*  0.0      VARIABLE tempeffb
*  0.0      VARIABLE tempefft
*  0.0      VARIABLE adjresval
*  0.0      VARIABLE r1Cur
*  0.0      VARIABLE r1TPwr
*  0.0      VARIABLE r1CurAC
*  0.0      VARIABLE r1PwrAC
*  0.0      VARIABLE r1CurDC
*  0.0      VARIABLE r1PwrDC
*  0.0      VARIABLE flag
*  0        VARIABLE nTime
*  0        VARIABLE nTimeCur
*
* : DELAY
*  *delaytime  0 do
*          *cnt 1+ ==>_*cnt
*          *cnt *delaytime =  if
*          *S_BLOWN 1 + ==>_*S_BLOWN
*          0 ==>_*cnt
*          endif
*   loop
*   *S_BLOWN ==>_*animation_state
* ;
*  : R_BLOWN
*        blown resistance GRADUAL_CHANGE_AT_RUN
*  ;
*
* : RESET
*       delay_factor 10000 * ==>_*delaytime
*       setval ==>_*adjresval
*       *adjresval 2.0 f./ ==>_*Rinit
*       ratedval ==>_*resrated
*       temp_set ==>_*restemp
*       alpha_tc_set ==>_*restca
*       beta_tc_set ==>_*restcb
*       tnom_set ==>_*restnom
*       0.0 ==>_*tempdiff
*       0.0 ==>_*tempeffa
*       0.0 ==>_*tempeffb
*       0.0 ==>_*tempefft
*       0.0 ==>_*flag
*       0.0 ==>_*r1TPwr
*       S_OK   ==>_*animation_state
*       0 ==>_*S_BLOWN
*       *Rinit resistance GRADUAL_CHANGE_AT_RUN
*       1 RESET_ACDC
*       2 RESET_ACDC
*       GET_LOCAL_TIME ==>_*nTime
* ;
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*       value SET_INSTANCE Resistor ::R r2 resistance
*  ;
*  :BEGIN_PLOT
*       RESET
*  ;
*
*  : ADJUST_RESISTANCE
*      *restemp *restnom f.- ==>_*tempdiff
*      *tempdiff *restca f.* ==>_*tempeffa
*      *tempdiff *tempdiff f.* *restcb f.* ==>_*tempeffb
*      *tempeffa 1.0 f.+ *tempeffb f.+ ==>_*tempefft
*      setval *tempefft f.* ==>_*adjresval
*  ;
*
*  :OUT_DATA
*      1.0 *flag f.> if
*          ADJUST_RESISTANCE
*          GET_INSTANCE Resistor ::R R1 i  ==>_*r1Cur
*          (( *r1Cur )) 1 ADD_ACDC
*          (( *r1Cur )) 2 ADD_ACDC
*          GET_LOCAL_TIME ==>_*nTimeCur
*          *nTimeCur *nTime - 6 >= if
*          (( 1 GET_DC )) ==>_*r1CurDC
*          (( 2 GET_AC )) ==>_*r1CurAC
*          *r1CurDC *r1CurDC f.* *adjresval f.* ==>_*r1PwrDC
*          *r1CurAC *r1CurAC f.* *adjresval f.* ==>_*r1PwrAC
*          *r1PwrDC *r1PwrAC f.+ ==>_*r1TPwr
*          *nTimeCur ==>_*nTime
*          endif
*      ratedval *r1TPwr f.< if
*          1.0 ==>_*flag
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          R_BLOWN
*     endif
*     endif
*  ;
* : BEGIN_ANALYSIS
*       RESET
*  ;
*
*  1 ACDC::ALLOC_INDEX
*  2 ACDC::ALLOC_INDEX
*
* : SIMULTATION_CHANGED
*      ACDC::CIRCUIT_CHANGE
*      GET_LOCAL_TIME ==>_*nTime
*  ;
*
* !!!END-INTERACT
xR1 3 4 virtual_resistanceR1
.subckt virtual_resistanceR1 1 2
R1 1 3 1000/2 pwres TEMP=27
.model pwres r(TC1=0 TC2=0 TNOM=27)
R2 3 2 1000/2
.ends

.MODEL 1N4148__SWITCHING_DIODE__1  D(Is=0.1p Rs=1.6 CJO=2p Tt=12n Bv=100 Ibv=0.1p)
