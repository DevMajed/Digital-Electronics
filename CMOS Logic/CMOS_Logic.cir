** CMOS_inverter **
*
* NI Multisim to SPICE Netlist Export
* Generated by: majed
* Thu, Jun 18, 2020 03:19:27
*

*## Multisim Component Q6 ##*
mQ6 2 Q6_OPEN_G 0 Q6_OPEN_SUB NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q5 ##*
mQ5 3 Q5_OPEN_G 2 Q5_OPEN_SUB NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q1 ##*
mQ1 3 Q1_OPEN_G 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q4 ##*
mQ4 1 Q4_OPEN_G 3 Q4_OPEN_SUB PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q2 ##*
mQ2 VDD Q2_OPEN_G 1 VDD PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component VDD ##*
VDDVDD  VDD 0 dc 5

*## Multisim Component Q3 ##*
mQ3 VDD Q3_OPEN_G 1 VDD PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Instrument XSC1 ##*

*## Multisim Component V1 ##*
vV1 V1_OPEN_1 0 ac 1 0
+   distof1 0 0
+   distof2 0 0
+   pulse(0 3.3 0 0 0 1e-007 2e-007)

.model NMOS__TRANSISTORS_VIRTUAL__1   nmos

.model PMOS__TRANSISTORS_VIRTUAL__1 pmos
